<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Blink_LED1_2_CubeMX.ewp</path>
  </project>
  <batchBuild />
</workspace>
